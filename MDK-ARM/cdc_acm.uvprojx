# Keil uVision project cdc_acm.uvprojx, settings and files
target cdc_acm (6220000::V6.22::ARMCLANG)
  device: GD32C103CB GigaDevice
  pack: GigaDevice.GD32C10x_DFP.1.0.1
  cpu: IRAM(0x20000000,0x08000) IROM(0x08000000,0x020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: DualCANFD-SLCAN
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: USE_STDPERIPH_DRIVER GD32C10X USE_USB_FS
  c include: ..\inc;..\Firmware\CMSIS\GD\GD32C10x\Include;..\Firmware\GD32C10x_standard_peripheral\Include;..\Firmware\GD32C10x_usbfs_library\driver\Include;..\Firmware\GD32C10x_usbfs_library\device\core\Include;..\Firmware\GD32C10x_usbfs_library\device\class\cdc\Include;..\Firmware\GD32C10x_usbfs_library\ustd\common;..\Firmware\GD32C10x_usbfs_library\ustd\class\cdc;..\Firmware\CMSIS\Core\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ../src/: main.c gd32c10x_hw.c gd32c10x_it.c systick.c can.c usart.c usb.c
  group CMSIS
    ../src/: startup_gd32c10x.s system_gd32c10x.c
  group Drivers
    ../Firmware/GD32C10x_standard_peripheral/Source/: gd32c10x_dma.c gd32c10x_exti.c gd32c10x_fmc.c gd32c10x_gpio.c gd32c10x_misc.c gd32c10x_pmu.c gd32c10x_rcu.c gd32c10x_timer.c gd32c10x_usart.c gd32c10x_ctc.c gd32c10x_dbg.c gd32c10x_can.c
  group USB
    ../Firmware/GD32C10x_usbfs_library/device/class/cdc/Source/: cdc_acm_core.c
    ../Firmware/GD32C10x_usbfs_library/device/core/Source/: usbd_transc.c usbd_enum.c usbd_core.c
    ../Firmware/GD32C10x_usbfs_library/driver/Source/: drv_usb_core.c drv_usb_dev.c drv_usbd_int.c
